# Keil uVision project Smart_Detection_Car.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Smart_Detection_Car +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c LCD12864.c GSM.c ds18b20.c beep.c IR.c DHT11.c
