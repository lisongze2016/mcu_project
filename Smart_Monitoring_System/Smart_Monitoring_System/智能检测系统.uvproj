# Keil uVision project 智能检测系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 智能检测系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: beep.c delay.c DHT11.c ds18b20.c LCD12864.c keyscan.c LCDMenu.c main.c GSM.c ADC0832.c
